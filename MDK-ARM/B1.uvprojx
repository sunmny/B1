# Keil uVision project B1.uvprojx, settings and files
target B1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476JEYx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: B1 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\Src\APP;..\Src\TASK;..\Src\GUI;..\Src\HARDWARE;..\Src\HARDWARE\gpio;..\Src\HARDWARE\led;..\Src\HARDWARE\key;..\Src\HARDWARE\lcd;..\Src\HARDWARE\adc;..\Src\HARDWARE\audio;..\Src\HARDWARE\board;..\Src\HARDWARE\charge;..\Src\HARDWARE\gps;..\Src\HARDWARE\gsensor;..\Src\HARDWARE\hartrate;..\Src\HARDWARE\lora;..\Src\HARDWARE\motor;..\Src\APP\QRENCODE;..\Src\HARDWARE\bd2;..\Src\HARDWARE\bd1;..\Src\HARDWARE\buzzer;..\Src\HARDWARE\key;..\Middlewares\Third_Party\FatFs\src;..\Src\nfc\comps\phTools\src;..\Src\nfc\comps\phbalReg\src\Stub;..\Src\nfc\comps\phhalHw\src\Rc523;..\Src\nfc\comps\phpalI14443p3a\src\Sw;..\Src\nfc\comps\phpalI14443p3b\src\Sw;..\Src\nfc\comps\phpalI14443p4a\src\Sw;..\Src\nfc\comps\phpalI14443p4\src\Sw;..\Src\nfc\comps\phTools\src;..\Src\nfc\comps\phKeyStore\src;..\Src\nfc\comps\phKeyStore\src\Sw;..\Src\nfc\types;..\Src\nfc\intfs;..\Src\nfc;..\Src
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_cortex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_uart.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_adc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sd.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_iwdg.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: queue.c list.c tasks.c croutine.c event_groups.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/User
    ../Src/: stm32l4xx_hal_msp.c main.c freertos.c stm32l4xx_it.c bd_tf.h beiDouTf.lib
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group APP
    ../Src/APP/: app_meerwespe.c my_common.c app_power.c app_bd1.c app_bd2.c app_ble.c app_lte.c zb_common_data.c app_nvram.c
    ./: app_nfc.c
  group TASK
    ../Src/TASK/: task_meerwespe.c task_gps.c task_ble.c task_lte.c task_bd1.c task_test.c task_sd.c
  group GUI
    ../Src/GUI/: gui_meerwespe.c
  group HARDWARE
    ../Src/HARDWARE/: hw_meerwespe.c delay.c
    ../Src/HARDWARE/board/: hw_gpio.c hw_i2c.c hw_uart.c hw_dma.c hw_exti.c hw_flash.c hw_battery.c
    ../Src/HARDWARE/bd2/: hw_bd2.c
    ../Src/HARDWARE/bd1/: hw_bd1.c
    ../Src/HARDWARE/buzzer/: hw_buzzer.c
    ../Src/HARDWARE/key/: hw_key.c
    ../Src/HARDWARE/sd/: hw_sd_init.c hw_diskio.c hw_driver_sd.c
    ./: hw_nfc.c
  group QRENCODE
    ../Src/APP/QRENCODE/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
  group FS
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c fatfs.c ff_gen_drv.c
  group NFC
    ../Src/nfc/: cpu_card.c fm175xx.c mifare_card.c type_a.c type_b.c type_f.c ultralight.c
software components: CMSIS:CORE 4.1.0
